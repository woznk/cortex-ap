# IAR project Backup of cortex-ap.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD_VL
  ICCARM.CCIncludePath2: ..\; ..\Libraries\CMSIS\CM3\CoreSupport; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Utilities
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: cortex-ap.srec
  ILINK.IlinkOutputFile: cortex-ap.out
  ILINK.IlinkIcfFile: cortex-ap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md_vl.s
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Discovery
    ../Utilities/: stm32f10x_it.c STM32vldiscovery.c
  group Drivers
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
  group User
    ../Source/: main.c
