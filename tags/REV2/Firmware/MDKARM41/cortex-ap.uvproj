# Keil uVision project cortex-ap.uvproj, settings and files
target cortex-ap Flash (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: cortex-ap
  c flags: Optim=2 oTime=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD_VL
  c include: .\;..\Utilities;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\fat_sd;..\Libraries\I2C_CPALV1.1.0;..\Libraries\I2C_MEMS_Driver;..\Libraries\L3G4200_Driver;..\Libraries\ADXL345_Driver;..\Libraries\BMP085_Driver;..\Libraries\FreeRTOSV7.1.0\Source\include;..\Libraries\FreeRTOSV7.1.0\Source\portable\RVDS\ARM_CM3;..\Libraries\Mavlink\matrixpilot;..\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../Source/: log.c main.c nav.c servodriver.c led.c vmath.c DCM.c ppmdriver.c PID.c attitude.c usart1driver.c mav_telemetry.c simulator.c
  group Libraries
    ../Libraries/L3G4200_Driver/: l3g4200d_driver.c
    ../Libraries/I2C_MEMS_Driver/: i2c_mems_driver.c
    ../Libraries/ADXL345_Driver/: ADXL345_driver.c
    ../Libraries/fat_sd/: sd_spi_stm32.c fattime.c ff.c
    ../Libraries/BMP085_Driver/: BMP085_driver.c
    ../Libraries/I2C_CPALV1.1.0/: cpal_usercallback.c cpal_hal.c cpal_i2c.c cpal_i2c_hal_stm32f10x.c
  group FreeRTOS
    ../Libraries/FreeRTOSV7.1.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../Libraries/FreeRTOSV7.1.0/Source/portable/RVDS/ARM_CM3/: port.c
    ../Libraries/FreeRTOSV7.1.0/Source/portable/MemMang/: heap_1.c
  group System
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_wwdg.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Utilities/: stm32f10x_it.c
    ../Source/: startup_stm32f10x_md_vl.s
target cortex-ap RAM (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: as above
  output: cortex-ap
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_LD_VL VECT_TAB_SRAM
  c include: .\;..\Utilities;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x20000000 size 0x1000
  memory RVCT9: RAM 0x20001000 size 0x1000
target Simulation (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: as above
  output: cortex-ap
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_LD_VL
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
