# Keil uVision project Test_Mavlink.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Test_Mavlink
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD_VL
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\FreeRTOSV7.1.0\Source\include;..\..\Libraries\FreeRTOSV7.1.0\Source\portable\RVDS\ARM_CM3;..\..\Source;..\..\Utilities;..\..\Libraries\Mavlink\matrixpilot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: test_mavlink.c usart1driver.c nav_stub.c attitude_stub.c
    ../../Source/: mav_telemetry.c
  group System
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
    ../../Source/: startup_stm32f10x_md_vl.s
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group FreeRTOS
    ../../Libraries/FreeRTOSV7.1.0/Source/: timers.c croutine.c list.c queue.c tasks.c
    ../../Libraries/FreeRTOSV7.1.0/Source/portable/MemMang/: heap_1.c
    ../../Libraries/FreeRTOSV7.1.0/Source/portable/RVDS/ARM_CM3/: port.c
