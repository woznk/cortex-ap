# Keil uVision project testpid.uvproj, settings and files
target Debug (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: cxap
  c flags: Optim=1 oTime=1
  c define: __heap_base__=Image$$RW_IRAM1$$ZI$$Limit __heap_end__=Image$$RW_IRAM2$$Base
  c include: ..\..\os\kernel\include;..\..\os\port\common\ARMCMx;..\..\os\port\common\ARMCMx\CMSIS\include;..\..\os\port\RVCT\ARMCMx;..\..\os\port\RVCT\ARMCMx\STM32F1xx;..\..\os\hal\include;..\..\os\hal\platforms\STM32;..\..\os\hal\platforms\STM32\GPIOv1;..\..\os\hal\platforms\STM32\I2Cv1;..\..\os\hal\platforms\STM32\SPIv1;..\..\os\hal\platforms\STM32\TIMv1;..\..\os\hal\platforms\STM32\USARTv1;..\..\os\hal\platforms\STM32F1xx;..\..\board;..\..\os\various;..\..\source;..\..\fatfs\src
  asm misc: --cpreproc
  asm include: ..\..\os\port\RVCT\ARMCMx;..\..\os\port\RVCT\ARMCMx\STM32F1xx;..\..\STM32F1xx\I2C;..\..\board;..\..\source
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x20020000 size 0x1
  group kernel
    ../../os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
  group port
    ../../os/port/common/ARMCMx/: nvic.c
    ../../os/port/RVCT/ARMCMx/: cstartup.s chcore.c chcore_v7m.c chcoreasm_v7m.s
    ../../os/port/RVCT/ARMCMx/STM32F1xx/: vectors.s
  group hal
    ../../os/hal/src/: uart.c hal.c pal.c serial.c i2c.c icu.c mmc_spi.c mmcsd.c pwm.c spi.c tm.c
    ../../os/hal/platforms/STM32/GPIOv1/: pal_lld.c
    ../../os/hal/platforms/STM32/USARTv1/: uart_lld.c serial_lld.c
    ../../os/hal/platforms/STM32F1xx/: hal_lld.c stm32_dma.c
    ../../os/hal/platforms/STM32/I2Cv1/: i2c_lld.c
    ../../os/hal/platforms/STM32/TIMv1/: icu_lld.c pwm_lld.c
    ../../os/hal/platforms/STM32/SPIv1/: spi_lld.c
  group board
    ../../board/: board.c
  group source
    ../../source/: control.c pid.c
    ./: main.c servo_stub.c dcm_stub.c mavlink_stub.c nav_stub.c rc_stub.c
target Release (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: as above
  output: cxap
  c flags: Optim=1 oTime=1
  c define: as above
  c include: ..\os\kernel\include;..\os\port\common\ARMCMx;..\os\port\common\ARMCMx\CMSIS\include;..\os\port\RVCT\ARMCMx;..\os\port\RVCT\ARMCMx\STM32F1xx;..\os\hal\include;..\os\hal\platforms\STM32;..\os\hal\platforms\STM32\GPIOv1;..\os\hal\platforms\STM32\I2Cv1;..\os\hal\platforms\STM32\SPIv1;..\os\hal\platforms\STM32\TIMv1;..\os\hal\platforms\STM32\USARTv1;..\os\hal\platforms\STM32F1xx;..\board;..\os\various;..\source;..\fatfs\src
  asm misc: --cpreproc
  asm include: ..\os\port\RVCT\ARMCMx;..\os\port\RVCT\ARMCMx\STM32F1xx;..\STM32F1xx\I2C;..\board;..\source
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x20020000 size 0x1
target Simulation (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: cxap
  c flags: Optim=1 oTime=1
  c define: as above
  c include: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  memory RVCT10: RAM 0x20020000 size 0x1
